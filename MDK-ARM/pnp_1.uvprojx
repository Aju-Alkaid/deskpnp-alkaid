# Keil uVision project pnp_1.uvprojx, settings and files
target pnp_1 (6220000::V6.22::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: pnp_1 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/ZeMCU-G4;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Task;../TouchGFX/target/generated;../TouchGFX/target;../TouchGFX/App;../st7306;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  asm include: E:/stm32cubemxRepository/STM32Cube_FW_G4_V1.6.1/Drivers/CMSIS/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c crc.c dma.c fdcan.c usart.c spi.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/ZeMCU-G4
    ../Drivers/ZeMCU-G4/: driver_spiflash_w25q64.c driver_timer.c driver_uart.c driver_uart.h driver_can.c driver_can.h driver_motor.c timestamp.c timestamp.h driver_drv8803.c driver_tmc2209.c driver_tmc2209.h tmc_protocol.c tmc_protocol.h pid.c pid.h driver_servo.c driver_servo.h driver_heater.c driver_heater.h key.c key.h ringbuf.h ringbuf.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Task
    ../Task/: app_test.c app_test.h Task_Init.c Task_Init.h app_motion.c app_motion.h app_host.c app_host.h app_uart_parser.c app_uart_parser.h app_vision.c app_vision.h
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: KeyController.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group gui
    ../touchgfx/gui/src/containers/: circleprogress.cpp detail.cpp pagetable.cpp
    ../touchgfx/gui/src/model/: data_transfer.c model.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/screen_home_screen/: screen_homepresenter.cpp screen_homeview.cpp
    ../touchgfx/gui/src/screen_import_screen/: screen_importpresenter.cpp screen_importview.cpp
    ../touchgfx/gui/src/screen_log_screen/: screen_logpresenter.cpp screen_logview.cpp
    ../touchgfx/gui/src/screen_reset_screen/: screen_resetpresenter.cpp screen_resetview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_comic_25_1bpp_0.cpp font_segoeui_23_1bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_comic_25_1bpp.cpp kerning_segoeui_23_1bpp.cpp table_comic_25_1bpp.cpp table_segoeui_23_1bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_add.cpp image_arrowleft.cpp image_arrowright.cpp image_circle-progress.cpp image_cross.cpp image_download.cpp image_download_selected.cpp image_home.cpp image_home_selected.cpp image_menu.cpp image_menu_selected.cpp image_message.cpp image_message_selected.cpp image_refre.cpp image_refre_selected.cpp image_setting.cpp image_setting_selected.cpp image_simple_down.cpp image_simple_left.cpp image_simple_right.cpp image_simple_up.cpp image_tick.cpp image_wifi_connected.cpp image_wifi_connected_selected.cpp image_wifi_disc.cpp image_wifi_disc_selected.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/containers/: circleprogressbase.cpp detailbase.cpp pagetablebase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/screen_home_screen/: screen_homeviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen_import_screen/: screen_importviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen_log_screen/: screen_logviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen_reset_screen/: screen_resetviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m4f/Keil6.x/: touchgfx_core_wchar32.lib
  group st7306
    ../st7306/: lcd.c lcd.h lcd_config.h
software components: CMSIS:CORE 5.6.0
